## nemu/configs/exam_defconfig
```kconfig
CONFIG_ISA_riscv64=y
CONFIG_CC_DEBUG=y
CONFIG_CC_ASAN=y
# CONFIG_TRACE is not set
CONFIG_DIFFTEST=y
CONFIG_DEVICE=y
```
